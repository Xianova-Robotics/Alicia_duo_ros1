Commit message: Add 6D grasp

File: alicia_duo_descriptions/urdf/alicia_gripper_original.urdf (robot description, URDF)
Before this commit: robot alicia_duo_descriptions, 13 links, 12 joints
Joints:
- joint Joint02: axis 0 0 1 -> 0 0 -1
- joint joint_tcp: parent gripper_control -> gripper_base
